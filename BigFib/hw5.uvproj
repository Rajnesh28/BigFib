# Keil uVision project hw5.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STR730FZ2 STMicroelectronics
  cpu: IRAM(0xA0000000-0xA0003FFF) IROM(0x80000000-0x8003FFFF) CLOCK(36000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  asm misc: --diag_suppress=A1450E,A1608W --cpreproc
  memory RVCT4: ROM 0x80000000 size 0x40000
  memory RVCT9: RAM 0xa0000000 size 0x4000
  group Startup Code
    ./: STR73x.s InitHw.c InitHw.h asm_include.h
  group Interrupts
    ./: 73x_it.c
  group System Calls
    ./: Retarget.c
  group Library
    C:/Keil_v5/ARM/RV31/LIB/ST/: STR73xR.LIB
  group Source Code
    ./: bigAdd.s BigFib.c main.c BigFib.h heapstats.h
  group Documentation
    ./: Abstract.txt
target STR730 Board - Flash (ARM-ADS)
  device: STR730FZ2 STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=4 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x80000000 size 0x40000
  memory RVCT9: RAM 0xa0000000 size 0x4000
